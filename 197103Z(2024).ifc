Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
Time: 2024-01-28T23:52:14
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20200210_1400(x64) - Exporter 20.2.12.1 - Alternate UI 20.2.12.1
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Sun Jan 28 23:52:14 2024 * Host: DESKTOP-13TP49N * Database: C:\Users\andre\AppData\Local\Temp\8f60cd24-d351-4d47-92a9-e92f049f2c17\ea061822-ca06-4db0-a21d-ecaccc7e17e9\ifc * Database version: 5507 * Database creation date: Sun Jan 28 23:52:12 2024 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Sun Jan 28 23:52:12 2024 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Sun Jan 28 23:52:12 2024 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcSite, Default
RefLatitude: 42, 24, 53, 508911; RefLongitude: -71, -15, -29, -58837; RefElevation: 0 mm
Other - Category: Project Information

# IfcBuilding
Other - Category: Project Information

# IfcBuildingStorey: Level:Level 1, Level 1
LongName: Level 1; Elevation: 0 mm
Other(Type) - Category: Levels; Family Name: Level
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no
Other - Category: Levels; Family: Level: Level 1; Family and Type: Level: Level 1; Type: Level: Level 1; Type Id: Level: Level 1
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Solid; Line Weight: 1; Symbol at End 1 Default: no; Symbol at End 2 Default: yes
Identity Data(Type) - Type Name: Level 1

# IfcFlowController: 197103Z Smart Bidetta unit, 9/230 V, Bluetooth, 197103Z(2024):197103Z Smart Bidetta unit, 9/230 V, Bluetooth:57304
In: Level 1
Type - PredefinedType: FAUCET
Type - Constraints - Default Elevation: 0 mm
Type - Dimensions - FaucetNominalDepth: 42.8786 mm; FaucetNominalHeight: 150.337 mm; FaucetNominalWidth: 314.956 mm; HandShowerNominalDepth: 66.9785 mm; HandShowerNominalHeight: 421.074 mm; HandShowerNominalWidth: 56.8083 mm; InletConnectionSize: 8 mm
Type - Electrical - Battery: CR 2450 3 V; Bluetooth: 5.x (D060577); Electrical Connection: 230 / 9 V; Operating Voltage: 9 V; Protection Class: IP 55
Type - General - Author: BIMStone; BIMObjectName: 197103Z(2024); ManufacturerName: Oras; ManufacturerURL: http://www.oras.com; NBSDescription: Shower mixers; NBSReference: 45-35-70/335; ProductInformation: Washbasin faucet with Bidetta hand shower; Revision: n/a; Uniclass2: Pr_40_30_96_78; Uniclass2015Description: Shower manual water supply sets; Uniclass2015Reference: Pr_40_20_87_78; Version: 1; VersionDate: 17/01/2024
Type - Green Building Properties - EAN Number: 6414150105135; EMC Directive: Radio Equipment Directive 2014/53/EU , Low Voltage Directive 2014/35/EU , EMC Directive 2014/30/EU , RoHS Directive 2011/65/EU; EN Standard: ETSI EN 301 489-1 V1.9.2 , ETSI EN 300 328 v2.2.2 , EN 61000-6-1:2007 , EN 61000-6-3:2007+A1:2011+AC:2012 , EN 60335-1:2012+A11+A13+A1+A14+A2+A15:2021, Part 19.11.4; URL Declaration of Asbestos: http://static.oras.com/doc/asbestos; URL Declaration of Conformity: http://static.oras.com/DoC/197103Z; URL Declaration Of Performance (DOP): http://static.oras.com/doc/DoP; URL Declaration of SCIP: http://static.oras.com/doc/SCIP; URL EcoLabel Declaration: http://static.oras.com/doc/EcoLabel; URL EU Packaging Declaration: http://static.oras.com/doc/packaging; URL REACH: http://static.oras.com/doc/reach; URL WEEE: http://static.oras.com/WEEE/197103Z
Type - Identity Data - 2D/3D/BIM Files URL: http://static.oras.com/bim/197103Z; Catalog Drawing URL: http://static.oras.com/catdrw/197103Z; Dimension Drawing URL: http://static.oras.com/dimdrw/197103Z; FDV Document URL: http://www.oras.com/datasheet/197103Z/en/fdv; Group: Smart accessory; Manufacturer: Oras; Market: International;Finland; Mobile Product Information URL: http://mpi.oras.com/197103Z; Model: 197103Z Smart Bidetta unit, 9/230 V, Bluetooth; Name_en: 197103Z Smart Bidetta unit, 9/230 V, Bluetooth; OmniClass Number: 23.45.55.00; OmniClass Title: Sanitary Faucets, Wastes; Product Code: 197103Z; Product Family: Oras Electra; Product Image URL: http://static.oras.com/image/197103Z; Product URL: http://static.oras.com/197103Z; Short Marketing: Smart Bidetta Thermostatic control unit maintains the requested water temperature when using the Smart Bidetta hand shower. The function of remote operated Smart Bidetta hand shower: when lifting the hand shower from the holder water starts to flow from bypass outlet in ejector (the water must flow freely from bypass outlet). When pressing the hand shower trigger the water supply transfers from faucet to hand shower. When placing the Smart Bidetta hand shower back to its holder the water flow closes automatically; Technical DataSheet URL: http://www.oras.com/datasheet/197103Z/en; Type Name: 197103Z Smart Bidetta unit, 9/230 V, Bluetooth; Warranty Information URL: http://warranty.oras.com
Type - Materials and Finishes - FaucetMainMaterial: Brass
Type - Mechanical - Automatic Flush Frequency: off (off/1-120 h); Automatic Flush Period: 30 s (1-1800 s); Electronic Parts: Solenoid valve;Power supply; Hand Shower: Remote-operated Smart Bidetta; Max Flow Period: 2 min (1 - 1800 s); Mechanical Parts: Thermostatic cartridge for automatic temperature control; Shower Parts: Hand shower;Shower holder;Shower hose (1500 mm); Shower Spray Number: 1 shower spray; Surface treatment: Chrome; Temperature: Temperature limiter
Type - Other - Category: Plumbing Fixtures; AccessibilityPerformance: n/a; AssetType: Fixed; Brand: Oras; CodePerformance: n/a; Color: Chrome; Constituents: n/a; DurationUnit: Year; ExpectedLife: n/a; Family Name: 197103Z(2024); Features: External transformer;Bluetooth®; Finish: Polished; Grade: n/a; ModelNumber: n/a; ModelReference: 197103Z; Name: 197103Z Smart Bidetta unit, 9/230 V, Bluetooth; ReplacementCost: n/a; Shape: Sculptured; Size: Faucet:50x155x140 mm / Hand shower: 46x64x286 mm; SustainabilityPerformance: n/a; WarrantyDescription: http://warranty.oras.com; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: Year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
Constraints - DistanceX-Axis: 300 mm; DistanceY-Axis: 100 mm; Elevation from Level: 0 mm; FaucetDefaultElevation: 900 mm; HandShowerDefaultElevation: 900 mm; Host: Level : Level 1; Level: Level: Level 1; Moves With Nearby Elements: no; Offset from Host: 0 mm
Dimensions - Area: 0.171804 m2; Volume: 0.00637157 m3
Identity Data - Mark: 25
Other - AssetIdentifier: n/a; Barcode: n/a; Family: 197103Z(2024): 197103Z Smart Bidetta unit, 9/230 V, Bluetooth; Family and Type: 197103Z(2024): 197103Z Smart Bidetta unit, 9/230 V, Bluetooth; InstallationDate: n/a; SerialNumber: n/a; TagNumber: n/a; Type: 197103Z(2024): 197103Z Smart Bidetta unit, 9/230 V, Bluetooth; Type Id: 197103Z(2024): 197103Z Smart Bidetta unit, 9/230 V, Bluetooth; WarrantyStartDate: n/a
Phasing - Phase Created: New Construction
